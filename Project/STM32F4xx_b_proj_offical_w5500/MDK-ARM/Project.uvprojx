# Keil uVision project Project.uvprojx, settings and files
target STM32F40_41xxx (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F40_41xxx +hex
  c flags: OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,USE_STM324xG_EVAL
  c misc: --C99
  c include: ../;../../../Libraries/CMSIS/Device/ST/STM32F4xx/Include;../../../Libraries/STM32F4xx_StdPeriph_Driver/inc;../../../Utilities/STM32_EVAL/Common;../../../Utilities/STM32_EVAL/STM3240_41_G_EVAL;..\pro_src;..\pro_src\spi_flash;..\pro_src\spi_net;..\pro_src\spi_adc;..\pro_src\bsp\inc;..\pro_src\usart_src;..\pro_src\bsp\xwf;..\pro_src\spi_net_w5500_offical
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../: system_stm32f4xx.c
  group Doc
    ../: readme.txt
  group bsp
    ../pro_src/bsp/xwf/: adc_spi.c flash_spi.c gpio.c tim.c usart.c tim9_driver.c
  group User
    ../: stm32f4xx_it.c main.c
  group usart_src
    ../pro_src/usart_src/: fifobuffer.c usart_app.c usart_driver.c
  group spi_flash
    ../pro_src/spi_flash/: Mx25L6406e.c Mx25L6406e_cmd.c spi_flash_driver.c
  group spi_net
    ../pro_src/spi_net/: socket.c w5500.c spi_net_driver.c dhcp.c
  group spi_adc
    ../pro_src/spi_adc/: spi_adc_app.c spi_adc_driver.c
  group STM32F4xx_StdPeriph_Driver
    ../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_flash.c stm32f4xx_dma2d.c stm32f4xx_pwr.c stm32f4xx_wwdg.c stm32f4xx_fmpi2c.c stm32f4xx_spi.c stm32f4xx_hash.c stm32f4xx_ltdc.c stm32f4xx_dfsdm.c stm32f4xx_dbgmcu.c stm32f4xx_sdio.c stm32f4xx_tim.c stm32f4xx_iwdg.c stm32f4xx_cryp.c stm32f4xx_flash_ramfunc.c stm32f4xx_rtc.c stm32f4xx_cryp_tdes.c stm32f4xx_cryp_aes.c stm32f4xx_adc.c stm32f4xx_cec.c stm32f4xx_cryp_des.c stm32f4xx_i2c.c stm32f4xx_spdifrx.c stm32f4xx_usart.c stm32f4xx_sai.c stm32f4xx_crc.c stm32f4xx_rng.c misc.c stm32f4xx_fsmc.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_dac.c stm32f4xx_lptim.c stm32f4xx_can.c stm32f4xx_dcmi.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_hash_md5.c stm32f4xx_gpio.c stm32f4xx_syscfg.c stm32f4xx_dma.c stm32f4xx_hash_sha1.c stm32f4xx_fmc.c
  group /MDK-ARM
    ../../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f427_437xx.s startup_stm32f469_479xx.s startup_stm32f411xe.s startup_stm32f446xx.s startup_stm32f412xg.s startup_stm32f401xx.s startup_stm32f410xx.s startup_stm32f40_41xxx.s startup_stm32f413_423xx.s startup_stm32f429_439xx.s
  group spi_net_w5500_offical
    ../pro_src/spi_net_w5500_offical/: loopback.c socket.c w5500.c wizchip_conf.c app_fifo.c
target STM32F401xx (ARM-ADS)
  device: STM32F401VCTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32F401xx
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F401xx
  c misc: --C99
  c include: ../;../../../Libraries/CMSIS/Device/ST/STM32F4xx/Include;../../../Libraries/STM32F4xx_StdPeriph_Driver/inc;../../../Utilities/STM32_EVAL/Common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
software components: CMSIS:CORE 5.0.1
